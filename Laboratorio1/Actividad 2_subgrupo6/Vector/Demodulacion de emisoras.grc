options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Receptor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '91700000'
  states: {}
- name: fcb
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del filtro
    start: '10000'
    step: '100'
    stop: '100000'
    value: '100000'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: fs
    start: 12500000/32
    step: '10000'
    stop: 12500000/2
    value: 12500000/2
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate/D
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/D
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Promedios de tiempos',   # will show up in GRC
                  in_sig=[np. float32 ],
                  out_sig=[np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.acum_anterior = 0
              self.Ntotales = 0
              self.acum_anterior1 = 0
              self.acum_anterior2 = 0
              self.acum_anterior3 = 0

          def work(self, input_items, output_items):
              x = input_items[0] # Senial de entrada .
              y0 = output_items[0] # Promedio de la senial
              y1 = output_items[1] # Media de la senial
              y2 = output_items[2] # RMS de la senial
              y3 = output_items[3] # Potencia promedio de la senial
              y4 = output_items[4] # Desviacion estandar de la senial
              
              # Calculo de la media
              N = len (x)
              self.Ntotales = self.Ntotales + N
              acumulado = self.acum_anterior + np.cumsum(x)
              self.acum_anterior = acumulado[N-1]
              y0[:] = acumulado /self.Ntotales
              
              # Calculo de la media cuadratica
              x2=np.multiply(x,x)
              acumulado1 = self.acum_anterior1 + np.cumsum(x2)
              self.acum_anterior1 = acumulado[N-1]
              y1[:]=acumulado1/self.Ntotales
              
              # Calculo de la RMS
              x3=np.multiply(x,x)
              acumulado3 = self.acum_anterior3+ np.cumsum(x3)
              self.acum_anterior3 = acumulado3[N-1]
              y2[:] = np.sqrt(acumulado3 / self.Ntotales)
              
              # Calculo de la potencia promedio
              y3[:] = np.multiply (y2 ,y2)
              
              # Calculo de la desviacion estandar
              x1 = np.multiply (x-y0 ,x-y0)
              acumulado2 = self.acum_anterior2 + np.cumsum(x1)
              self.acum_anterior2 = acumulado2 [N -1]
              y4[:] = np.sqrt(acumulado2/self.Ntotales)
              
              

              return len(x)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcb
    decim: D
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '16384'
    name: '"SEÑAL RECIBIDA"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    name: señal demodulada
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media cuadratica
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Valor RMS
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencia Promedio
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Desviacion Estandar
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/D)
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_1, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', epy_block_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_1, '0']
- [epy_block_0, '2', qtgui_number_sink_2, '0']
- [epy_block_0, '3', qtgui_number_sink_3, '0']
- [epy_block_0, '4', qtgui_number_sink_4, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
